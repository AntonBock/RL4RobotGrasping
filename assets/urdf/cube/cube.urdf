Commit message: ADD: Random objects

File: assets/urdf/cube/cube.urdf (robot description, URDF)
Before this commit: robot cube_v, 1 links, 0 joints
Links:
- link cube_v__link_2: geometry collision box size=0.05 0.05 0.05; visual box size=0.05 0.05 0.05
